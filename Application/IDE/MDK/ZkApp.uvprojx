# Keil uVision project ZkApp.uvprojx, settings and files
target ZkApp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKE16Z32VLD4 NXP
  pack: NXP.MKE16Z4_DFP.11.0.0
  cpu: IRAM(0x1ffffc00,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ZkApp +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Core;..\..\Core\Include;..\..\Driver\DrvTimer;..\..\Driver\DrvUart;..\..\Driver\DrvGpio;..\..\Driver\DrvFlash;..\..\Driver\DrvWdt;..\..\Driver\DrvADC;..\..\Driver\DrvCan;..\..\App\Configure;..\..\Protocol;..\..\Protocol\ZkPtl;..\..\Log;..\..\Peripheral\PowerMonitor
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  scatter file: .\MKE16_FlashMap.sct
  link misc: --remove
  group App
    ../../App/: main.c App.c
    ../../App/Configure/: AppTag.c
  group Core
    ../../Core/: startup_MKE16Z4.s System.c
  group Driver
    ../../Driver/DrvTimer/: DrvTimer.c
    ../../Driver/DrvUart/: DrvUart.c
    ../../Driver/DrvGpio/: DrvGpio.c
    ../../Driver/DrvFlash/: DrvFlash.c
    ../../Driver/DrvWdt/: DrvWdt.c
    ../../Driver/DrvADC/: DrvADC.c
    ../../Driver/DrvCan/: DrvCan.c
  group Protocol
    ../../Protocol/ZkPtl/: ZkPtl.c ZkPtlLowlevel.c
  group Peripheral
    ../../Peripheral/PowerMonitor/: PowerMonitor.c
  group Log
    ../../Log/: DebugMsg.c
